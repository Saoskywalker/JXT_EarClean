# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libary\Device\CMS8S6990\Include;..\Libary\StdDriver\inc;..\code;..\..\..\..\board\ear_clean_v01\include;..\port\include;..\..\public\include;..\..\..\..\user_src\include
  link misc: REMOVEUNUSED
  group CMS
    ../Libary/Device/CMS8S6990/Include/: cms8s6990.h
    ../Libary/Device/CMS8S6990/: startup_cms8s6990.A51
  group CMS_LIB
    ../Libary/StdDriver/src/: adc.c epwm.c extint.c flash.c gpio.c lse.c pga.c system.c timer.c uart.c wdt.c
  group User
    ../code/: isr.c
    ../../../../user_src/: display_define.c EarClean_timer.c envent_define.c main.c
  group platform_port
    ../port/: adc_port.c delay.c pwm_port.c timer_port.c watch_dog_port.c uart_port.c
  group board
    ../../../../board/ear_clean_v01/: adc_board.c display_board.c gpio_board.c key_board.c
